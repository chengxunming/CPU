# Keil uVision project L50T-CPU.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: L50T-CPU +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --C99
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\USER;..\BSP;..\Driver;..\Ethernet;..\Ethernet\W5500;..\LIB\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.c sys.c delay.c
  group BSP
    ../BSP/: bsp.c bsp_net.c bsp_pcf8563.c bsp_rs485.c bsp_rs232.c bsp_led.c
  group Ethernet
    ../Ethernet/W5500/: w5500.c
    ../Ethernet/: socket.c wizchip_conf.c
  group Driver
    ../Driver/: ssp.c I2CINT.c time.c LPC1700CAN.c uart.c dma.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC177x_8x.c
  group STARTCODE
    ../STARTCODE/: startup_LPC177x_8x.s
software components: CMSIS:CORE 5.0.1
